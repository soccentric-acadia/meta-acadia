SUMMARY = "Acadia Oil & Gas image (placeholder)"
DESCRIPTION = "Placeholder Oil & Gas image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Oil & Gas-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
