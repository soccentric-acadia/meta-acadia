SUMMARY = "Acadia Transportation & Rail image (placeholder)"
DESCRIPTION = "Placeholder Transportation & Rail image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Transportation & Rail-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
