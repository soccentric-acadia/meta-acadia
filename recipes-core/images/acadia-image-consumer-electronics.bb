SUMMARY = "Acadia Consumer Electronics image (placeholder)"
DESCRIPTION = "Placeholder Consumer Electronics image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Consumer Electronics-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
