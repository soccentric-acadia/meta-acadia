SUMMARY = "Acadia Defense image (placeholder)"
DESCRIPTION = "Placeholder Defense image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Defense-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
