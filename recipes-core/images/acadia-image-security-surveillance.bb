SUMMARY = "Acadia Security & Surveillance image (placeholder)"
DESCRIPTION = "Placeholder Security & Surveillance image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Security & Surveillance-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
