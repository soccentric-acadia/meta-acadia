SUMMARY = "Acadia Medical Devices image (placeholder)"
DESCRIPTION = "Placeholder Medical Devices image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Medical Devices-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
