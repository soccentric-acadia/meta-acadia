SUMMARY = "Acadia Retail / Point-of-Sale image (placeholder)"
DESCRIPTION = "Placeholder Retail / Point-of-Sale image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Retail / Point-of-Sale-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
