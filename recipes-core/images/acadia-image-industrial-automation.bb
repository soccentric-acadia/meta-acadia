SUMMARY = "Acadia Industrial Automation image (placeholder)"
DESCRIPTION = "Placeholder Industrial Automation image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Industrial Automation-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
