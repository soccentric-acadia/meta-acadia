SUMMARY = "Acadia Agriculture (AgTech) image (placeholder)"
DESCRIPTION = "Placeholder Agriculture (AgTech) image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Agriculture (AgTech)-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
