SUMMARY = "Acadia Mining image (placeholder)"
DESCRIPTION = "Placeholder Mining image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Mining-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
