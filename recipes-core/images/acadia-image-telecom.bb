SUMMARY = "Acadia Telecommunications image (placeholder)"
DESCRIPTION = "Placeholder Telecommunications image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Telecommunications-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
