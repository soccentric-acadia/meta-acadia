SUMMARY = "Acadia Robotics image (placeholder)"
DESCRIPTION = "Placeholder Robotics image for the Acadia platform."
LICENSE = "MIT"

require recipes-extended/images/core-image-full-cmdline.bb

# TODO: add Robotics-specific packages, features, and configuration
IMAGE_INSTALL:append = ""
